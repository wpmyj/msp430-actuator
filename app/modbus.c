/**
 * @file  modbus.c
 * @brief modbus协议实现
 * @version 1.0
 * @author ygz <yangguozheng@tjwzkj.com>
 * @date   2015.7.1
 */
#include "modbus.h"
#include "app.h"

typedef u8 UCHAR;     ///< UCHAR类型定义
typedef u16 USHORT;   ///< USHORT类型定义

/**
 * @brief crc校验高位表
 */
static const UCHAR aucCRCHi[] = {
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
  0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
  0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40
};

/**
 * @brief crc校验低位表
 */
static const UCHAR aucCRCLo[] = {
  0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7,
  0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E,
  0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9,
  0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC,
  0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
  0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32,
  0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D,
  0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 
  0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF,
  0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
  0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1,
  0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4,
  0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 
  0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA,
  0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
  0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0,
  0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97,
  0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E,
  0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89,
  0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
  0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83,
  0x41, 0x81, 0x80, 0x40
};

/**
 * @brief crc16校验
 * @param[in] pucFrame 数据
 * @param[in] usLen 数据长度
 * @retval 校验值
 */
USHORT
usMBCRC16( UCHAR * pucFrame, USHORT usLen )
{
  UCHAR           ucCRCHi = 0xFF;
  UCHAR           ucCRCLo = 0xFF;
  int             iIndex;
  
  while( usLen-- )
  {
    iIndex = ucCRCLo ^ *( pucFrame++ );
    ucCRCLo = ( UCHAR )( ucCRCHi ^ aucCRCHi[iIndex] );
    ucCRCHi = aucCRCLo[iIndex];
  }
  return ( USHORT )( ucCRCHi << 8 | ucCRCLo );
}

/**
 * @brief modbus-rtu请求协议打包（读多寄存器）
 * @param[in] slave 从机地址
 * @param[in] addr 寄存器起始地址
 * @param[in] len 数据长度
 * @param[out] out_buf 打包数据输出
 * @param[out] out_len 打包数据长度
 * @retval RTU_REQ 成功
 */
u8 modbus_read_registers_pack(u8 slave, u16 addr, u16 len, 
                              u8 *out_buf, u16 *out_len) {
  out_buf[0] = slave;
  out_buf[1] = 0x03;
  out_buf[2] = addr>>8;
  out_buf[3] = addr&0xFF;
  out_buf[4] = len>>8;
  out_buf[5] = len&0xFF;
  u16 crc_0 = usMBCRC16(out_buf, 6);
  out_buf[6] = crc_0&0xFF;
  out_buf[7] = crc_0>>8;
  *out_len = 8;
  return RTU_REQ;
}

/**
 * @brief modbus-rtu请求协议打包（读多寄存器 04 input registers）
 * @param[in] slave 从机地址
 * @param[in] addr 寄存器起始地址
 * @param[in] len 数据长度
 * @param[out] out_buf 打包数据输出
 * @param[out] out_len 打包数据长度
 * @retval RTU_REQ 成功
 */
u8 modbus_read_input_registers_pack(u8 slave, u16 addr, u16 len, 
                              u8 *out_buf, u16 *out_len) {
  out_buf[0] = slave;
  out_buf[1] = 0x04;
  out_buf[2] = addr>>8;
  out_buf[3] = addr&0xFF;
  out_buf[4] = len>>8;
  out_buf[5] = len&0xFF;
  u16 crc_0 = usMBCRC16(out_buf, 6);
  out_buf[6] = crc_0&0xFF;
  out_buf[7] = crc_0>>8;
  *out_len = 8;
  return RTU_REQ;
}

/**
 * @brief modbus-rtu请求协议打包（写单寄存器）
 * @param[in] slave 从机地址
 * @param[in] addr 寄存器起始地址
 * @param[in] value 数据
 * @param[out] out_buf 打包数据输出
 * @param[out] out_len 打包数据长度
 * @retval RTU_REQ 成功
 */
u8 modbus_write_register_pack(u8 slave, u16 addr, u16 value, 
                              u8 *out_buf, u16 *out_len) {
  out_buf[0] = slave;
  out_buf[1] = 0x06;
  out_buf[2] = addr>>8;
  out_buf[3] = addr&0xFF;
  out_buf[4] = value>>8;
  out_buf[5] = value&0xFF;
  u16 crc_0 = usMBCRC16(out_buf, 6);
  out_buf[6] = crc_0&0xFF;
  out_buf[7] = crc_0>>8;
  *out_len = 8;
  return RTU_REQ;
}

/**
 * @brief modbus-rtu请求协议打包（写多寄存器）
 * @param[in] slave 从机地址
 * @param[in] addr 寄存器起始地址
 * @param[in] v_len 数据长度
 * @param[out] out_buf 打包数据输出
 * @param[out] out_len 打包数据长度
 * @retval RTU_REQ 成功
 */
u8 modbus_write_registers_pack(u8 slave, u16 addr, u16 v_len,
                               u8 *out_buf, u16 *out_len) {
  out_buf[0] = slave;
  out_buf[1] = 0x10;
  out_buf[2] = addr>>8;
  out_buf[3] = addr&0xFF;
  out_buf[4] = v_len>>8;
  out_buf[5] = v_len&0xFF;
  u8 blen = v_len<<1;
  out_buf[6] = blen;
  u16 crc_0 = usMBCRC16(out_buf, 7 + blen);
  out_buf[7 + blen] = crc_0&0xFF;
  out_buf[7 + blen + 1] = crc_0>>8;
  *out_len = 7 + blen + 2;
  return RTU_REQ;
}

/**
 * @brief modbus-rtu协议(回复处理) 
 * @param[in] in_buf 输入数据
 * @param[in] in_len 数据长度
 * @param[in] req_buf 请求数据
 * @param[out] out_buf 寄存器指针
 * @param[out] out_len 寄存器数量
 * @retval RTU_REQ 成功
 */
u8 modbus_rep_handler(u8 *in_buf, u16 in_len, u8 *req_buf, 
                      u8 **out_buf, u16 *out_len) {
  if(in_buf[0] != req_buf[0] || in_buf[1] != req_buf[1]) {
    return RTU_ERR;
  }
  if(0x03 == in_buf[1] 
     && in_len == (5 + 2 * (req_buf[4]<<8 | req_buf[5])) 
     && in_buf[2] == 2 * (req_buf[4]<<8 | req_buf[5])){
    *out_buf = in_buf + 3;
    *out_len = 2 * (req_buf[4]<<8 | req_buf[5]);
    return RTU_REP;
  } else if(0x04 == in_buf[1] 
     && in_len == (5 + 2 * (req_buf[4]<<8 | req_buf[5])) 
     && in_buf[2] == 2 * (req_buf[4]<<8 | req_buf[5])){
    *out_buf = in_buf + 3;
    *out_len = 2 * (req_buf[4]<<8 | req_buf[5]);
    return RTU_REP;
  } else if(0x06 == in_buf[1] && 8 == in_len) {
    if(in_buf[2] == req_buf[2] 
       && in_buf[3] == req_buf[3]
       && in_buf[4] == req_buf[4]
       && in_buf[5] == req_buf[5]) {
         *out_buf = NULL;
         *out_len = 0;
         return RTU_REP;
       }
  } else if(0x10 == in_buf[1] && 8 == in_len) {
    if(in_buf[2] == req_buf[2] 
       && in_buf[3] == req_buf[3]
       && in_buf[4] == req_buf[4]
       && in_buf[5] == req_buf[5]) {
         *out_buf = NULL;
         *out_len = 0;
         return RTU_REP;
       }
  }
  return RTU_ERR;
}

/**
 * @brief modbus-rtu协议处理
 * @param[in] in_buf 输入数据
 * @param[in] in_len 数据长度
 * @param[out] out_buf 寄存器指针
 * @param[out] out_len 寄存器数量
 * @retval RTU_REQ 请求
 * @retval RTU_ERR 解析错误
 * @retval RTU_REP 回复
 */
u8 modbus_handler(u8 slave, u8 master, u8 *in_buf, u16 in_len, u8 *out_buf, u16 *out_len) {
  if((in_len >= 4)
     && (0 == usMBCRC16(( UCHAR * )in_buf, in_len)))
  {
//    USHORT sum0 = usMBCRC16(( UCHAR * )in_buf, in_len);
//    if(0 != sum0) {
//      return RTU_ERR;
//    }
    if(in_buf[0] < 0x01 || in_buf[0] > 0x99) {
      return RTU_ERR;
    }
    
    if(COM_MODE_MASTER == master) {
      return RTU_REP;
    } else if(slave != in_buf[0]) {
      return RTU_SLAVE_ERR;
    }
    
    if(0x03 != in_buf[1] && 0x06 != in_buf[1] && 0x10 != in_buf[1] && 0x04 != in_buf[1]) {
      return RTU_ERR;
    }
    u16 addr = ((in_buf[2] << 8) | in_buf[3]);
    out_buf[0] = in_buf[0];
    out_buf[1] = in_buf[1];
    
    if(0x03 == in_buf[1] || 0x04 == in_buf[1]) {
      u16 len = ((in_buf[4] << 8) | in_buf[5]);
      if(len < 0x01 || len > 0x7d) {
        return RTU_ERR;
      }
      out_buf[2] = len<<1;
      *out_len = 3 + out_buf[2] + 2;
      if(FALSE == read_registers(in_buf[0], addr, len, out_buf + 3)){
        return RTU_ERR;
      } else {
        u16 crc_0 = usMBCRC16(out_buf, 3 + out_buf[2]);
        out_buf[3 + out_buf[2]] = crc_0&0xFF;
        out_buf[3 + out_buf[2] + 1] = crc_0>>8;
        return RTU_REQ;
      }
    } else if(0x06 == in_buf[1]) {
      out_buf[2] = in_buf[2];
      out_buf[3] = in_buf[3];
      out_buf[4] = in_buf[4];
      out_buf[5] = in_buf[5];
      out_buf[6] = in_buf[6];
      out_buf[7] = in_buf[7];
      *out_len = 8;
      if(FALSE == write_registers(in_buf[0], addr, 1, in_buf + 4)){
        return RTU_ERR;
      } else {
        return RTU_REQ;
      }
    } else if(0x10 == in_buf[1]) {
      u16 len = ((in_buf[4] << 8) | in_buf[5]);
      if(len < 0x01 || len > 0x7d) {
        return RTU_ERR;
      }
      *out_len = 8;
      if(FALSE == write_registers(in_buf[0], addr, len, in_buf + 7)){
        return RTU_ERR;
      } else {
        out_buf[2] = in_buf[2];
        out_buf[3] = in_buf[3];
        out_buf[4] = in_buf[4];
        out_buf[5] = in_buf[5];
        u16 crc_0 = usMBCRC16(out_buf, 6);
        out_buf[6] = crc_0&0xFF;
        out_buf[7] = crc_0>>8;
        return RTU_REQ;
      }
    }
  }
  return RTU_ERR;
}