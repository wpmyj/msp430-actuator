# IAR project WZF6002_Actuator.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 512
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group app
    app/: actuator.c actuator.h adc_task.c adc_task.h app.c app.h button_task.c button_task.h debug_uart_task.c debug_uart_task.h flash_task.c flash_task.h flowmeter_task.c flowmeter_task.h lcd_font.c lcd_font.h lcd_task.c lcd_task.h led_task.c led_task.h modbus.c modbus.h motor_task.c motor_task.h protocol.c protocol.h register_map.c register_map.h rtu_task.c rtu_task.h test.c test.h upgrade_task.c upgrade_task.h watchdog_task.c watchdog_task.h
  group drivers
    drivers/: adc.c adc.h button.c button.h drivers.c drivers.h flash.c flash.h infra-red.c infra-red.h lcd.c lcd.h led.c led.h motor.c motor.h uart.c uart.h
  group kernel
    kernel/: cpu.c cpu.h kernel.c kernel.h stdint.c stdint.h task.c task.h watchdog.h
